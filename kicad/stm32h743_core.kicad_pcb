# Repository changgeruoxiao/hagent

File README.md:

# STM32H743ZIT6 核心板 · 全自动 EDA 设计流水线

> 规格书驱动、脚本自动生成的 STM32H743ZIT6 最小系统核心板：原理图 → PCB 布局布线 → DRC/语义门禁 → 制造文件。当前处于自动 EDA 流程整改与层策略实验阶段。

## 项目是什么

一块 **STM32H743ZIT6（LQFP144, Cortex-M7 @ 480MHz）最小系统核心板**，以及生成它的**自动化 EDA 流水线**：

- 85×65mm 四层板，USB-C 供电，TPS54331 DCDC，8MHz HSE + 32.768kHz LSE，SWD + USB（DFU），双排 2×28 引出 GPIO
- 原理图、网表、PCB、DRC、Gerber 由 Python/KiCad/Freerouting 流水线生成；人工负责规格决策、规则审查与最终视觉复核
- 附带 [方法论与流程记录](doc/方法论与流程记录.md) 与本地 Agent 执行计划，记录自动 EDA 的真源链、门禁和实验结果

## 仓库结构

```text
├── STM32H743ZIT6_核心板设计规格书.md   # 设计规格（人审输入）
├── doc/                              # 参考资料、方法论、Agent 执行计划
├── kicad/                            # EDA 产物与当前 build_status
└── tools/                            # 生成、布线编排与独立门禁脚本
```

关键脚本：

- `tools/gen_schematic.py`：生成 schematic，并强制从当前 schematic 重导 `.net`
- `tools/check_netlist.py`：独立网表语义门禁
- `tools/gen_pcb.py`：PCB/DSN 生成器
- `tools/pipeline_pcb.py`：DSN 分类、Freerouting、回写、DRC 与制造文件编排
- `tools/check_layer_policy.py`：内层设计意图门禁
- `tools/check_schematic_parity.py`：schematic/PCB 语义 parity 门禁
- `tools/release_gate.py`：artifact lineage + netlist + layer policy + DRC + parity 的最终发布门禁

## 快速复现

环境：KiCad 10（含自带 Python）、Python 3.10+、Freerouting v2.4.x。

```bash
# 1. 原理图 + 当前网表
python tools/gen_schematic.py
python tools/check_netlist.py

# 2. PCB / DSN
"<KiCad>/bin/python.exe" tools/gen_pcb.py
python tools/pipeline_pcb.py dsn

# 3. 自动布线
python tools/pipeline_pcb.py route --max-passes 5

# 4. SES 回写 / zones / DRC
"<KiCad>/bin/python.exe" tools/finish_pcb.py
python tools/pipeline_pcb.py drc

# 5. 完整发布门禁
python tools/release_gate.py

# 6. 制造文件：pipeline 会再次强制执行 release gate，失败则禁止导出
python tools/pipeline_pcb.py fab
```

## 设计依据

主要参考：ST AN4938、DS12110、ES0392、官方 NUCLEO-H743ZI2 参考设计，以及 TI TPS54331 数据手册；本地参考登记见 `doc/`。

## 当前状态

> **CURRENT STATUS: WIP / NOT FAB-READY**
>
> 当前正在验证四层板层策略与自动布线可收敛性。只有 `tools/release_gate.py` **PASS** 才允许生成新的制造文件。

当前已确认：

- schematic → netlist artifact lineage 已改为强制重导；TPS54331 `SS -> C28 10nF -> GND` 已进入正式真源链；
- In1.Cu 为 GND-only 硬约束；Experiment B 对 In2.Cu 采用 `+3V3 + 显式普通 GPIO 白名单`，敏感/语义网络默认禁止进入；
- 当前签入的 PCB/DRC 仍是失败实验产物，`kicad/build_status.json` 为事实状态文件；
- 上一轮 Experiment B 曾误把普通信号按 0.50mm 电源线宽路由，因此其 44/54 未连通数据**不能作为层策略优劣结论**；需由本地 Agent 在 0.20mm signal width 下重跑；
- 当前仓库不应把已有 `gerbers/` 视作可投板 Release Candidate。

关于当前 clearance：报告中存在约 0.10–0.149mm 的项目；其中低于 0.127mm 的项目不能描述为满足 0.127mm 工艺下限，最终必须以选定板厂/工艺规则和 Release Gate 为准。

## 许可

代码与设计文件以 [MIT](LICENSE) 发布。`doc/` 内的 ST/TI 版权文档（数据手册/应用笔记/官方原理图）版权归原作者所有，仅作本地参考，请遵循原厂商条款使用。

## KiCad design kicad/stm32h743_core.kicad_pcb

Parts:
C20, C23, C45, C47: 100n; C_0402_1005Metric
C21, C22: 10uF; C_0805_2012Metric
C24, C25: 47uF; C_1206_3216Metric
C26: 1nF; C_0402_1005Metric
C27: 47pF; C_0402_1005Metric
C28: 10n; C_0402_1005Metric
C40, C41: 2.2uF; C_0603_1608Metric
C42, C44, C46: 1uF; C_0603_1608Metric
C43, C48, C54, C55, C60, C61, C62, C63, C64, C65, C66, C67, C68, C69, C70: 100nF; C_0402_1005Metric
C50, C51, C52, C53: 18pF; C_0402_1005Metric
C71, C72: 4.7uF; C_0603_1608Metric
D5, D6, D7: SS34; D_SMA
D8: PWR_GREEN; LED_0603_1608Metric
D9: USER_BLUE; LED_0603_1608Metric
F1: 500mA; Fuse_1206_3216Metric
FB1: 600R@100MHz; L_0603_1608Metric
J1, J2: GPIO; PinHeader_2x28_P2.54mm_Vertical
J3: USB_C; USB_C_Receptacle_HRO_TYPE-C-31-M-12
J4: SWD; PinHeader_1x06_P2.54mm_Vertical
J5: BOOT; PinHeader_1x03_P2.54mm_Vertical
J6: 5VIN; PinHeader_1x02_P2.54mm_Vertical
L1: 6.8uH/4A; L_Bourns_SRP7028A_7.3x6.6mm
R10, R11: 5.1k; R_0402_1005Metric
R12: 68k; R_0402_1005Metric; not fitted
R13: 100k; R_0402_1005Metric; not fitted
R14: 0R; R_0805_2012Metric
R15: 10.2k; R_0402_1005Metric
R16: 3.24k; R_0402_1005Metric
R17: 29.4k; R_0402_1005Metric
R20, R21: 0R; R_0402_1005Metric
R22: 10k; R_0402_1005Metric
R23: 100k; R_0402_1005Metric
R24, R25: 1k; R_0402_1005Metric
SW1: NRST_KEY; SW_PUSH_6mm
SW2: USER_KEY; SW_PUSH_6mm
TP1: +3V3; TestPoint_Pad_D1.0mm
TP2: GND; TestPoint_Pad_D1.0mm
TP3: VCAP; TestPoint_Pad_D1.0mm
TP4: NRST; TestPoint_Pad_D1.0mm
TP5: BOOT0; TestPoint_Pad_D1.0mm
TP6: 3V3_SW; TestPoint_Pad_D1.0mm
U1: STM32H743ZIT6; LQFP-144_20x20mm_P0.5mm
U2: TPS54331DDAR; SOIC-8-1EP_3.9x4.9mm_P1.27mm_EP2.29x3mm
U3: USBLC6-2SC6; SOT-23-6
X1: 8MHz; Crystal_SMD_3215-2Pin_3.2x1.5mm
X2: 32.768kHz; Crystal_SMD_3215-2Pin_3.2x1.5mm

Connections:
3V3_SW: C24.1, C25.1, L1.2, R14.1, R15.1, TP6.1
5VIN: D6.2 (A), J6.1
BOOT: C23.1, U2.1 (BOOT)
BOOT0: J5.2, R23.1, TP5.1, U1.138 (BOOT0)
CC1: J3.A5 (CC1), R10.1
CC2: J3.B5 (CC2), R11.1
COMP: C27.1, R17.1, U2.6 (COMP)
COMP_M: C26.1, R17.2
FB: R15.2, R16.1, U2.5 (VSENSE)
LED_PWR: D8.2 (A), R24.2
LED_USER: D9.2 (A), R25.2
NRST: C54.1, J4.5, SW1.1, TP4.1, U1.25 (NRST)
OSC32_IN: C52.1, U1.8 (PC14), X2.1
OSC32_OUT: C53.1, U1.9 (PC15), X2.2
OSC_IN: C50.1, U1.23 (PH0), X1.1
OSC_OUT: C51.1, U1.24 (PH1), X1.2
PA0: J1.1, U1.34 (PA0)
PA1: J1.2, U1.35 (PA1)
PA2: J1.5, U1.36 (PA2)
PA3: J1.6, U1.37 (PA3)
PA4: J1.7, U1.40 (PA4)
PA5: J1.8, U1.41 (PA5)
PA6: J1.9, U1.42 (PA6)
PA7: J1.10, U1.43 (PA7)
PA8: J1.11, U1.100 (PA8)
PA9: J1.12, U1.101 (PA9)
PA10: J1.3, U1.102 (PA10)
PA13: J4.2, U1.105 (PA13)
PA14: J4.3, U1.109 (PA14)
PA15: J1.4, U1.110 (PA15)
PB0: D9.1 (K), J1.13, U1.46 (PB0)
PB1: J1.14, U1.47 (PB1)
PB2: J1.21, U1.48 (PB2)
PB3: J4.4, U1.133 (PB3)
PB4: J1.22, U1.134 (PB4)
PB5: J1.23, U1.135 (PB5)
PB6: J1.24, U1.136 (PB6)
PB7: J1.25, U1.137 (PB7)
PB8: J1.26, U1.139 (PB8)
PB9: J1.27, U1.140 (PB9)
PB10: J1.15, U1.69 (PB10)
PB11: J1.16, U1.70 (PB11)
PB12: J1.17, U1.73 (PB12)
PB13: J1.18, U1.74 (PB13)
PB14: J1.19, U1.75 (PB14)
PB15: J1.20, U1.76 (PB15)
PC0: J1.28, U1.26 (PC0)
PC1: J1.29, U1.27 (PC1)
PC2_C: J1.34, U1.28 (PC2_C)
PC3_C: J1.35, U1.29 (PC3_C)
PC4: J1.36, U1.44 (PC4)
PC5: J1.37, U1.45 (PC5)
PC6: J1.38, U1.96 (PC6)
PC7: J1.39, U1.97 (PC7)
PC8: J1.40, U1.98 (PC8)
PC9: J1.41, U1.99 (PC9)
PC10: J1.30, U1.111 (PC10)
PC11: J1.31, U1.112 (PC11)
PC12: J1.32, U1.113 (PC12)
PC13: C55.1, J1.33, SW2.1, U1.7 (PC13)
PD0: J1.42, U1.114 (PD0)
PD1: J1.43, U1.115 (PD1)
PD2: J1.50, U1.116 (PD2)
PD3: J1.51, U1.117 (PD3)
PD4: J1.52, U1.118 (PD4)
PD5: J1.53, U1.119 (PD5)
PD6: J2.1, U1.122 (PD6)
PD7: J2.2, U1.123 (PD7)
PD8: J2.3, U1.77 (PD8)
PD9: J2.4, U1.78 (PD9)
PD10: J1.44, U1.79 (PD10)
PD11: J1.45, U1.80 (PD11)
PD12: J1.46, U1.81 (PD12)
PD13: J1.47, U1.82 (PD13)
PD14: J1.48, U1.85 (PD14)
PD15: J1.49, U1.86 (PD15)
PDR_ON: R22.1, U1.143 (PDR_ON)
PE0: J2.5, U1.141 (PE0)
PE1: J2.6, U1.142 (PE1)
PE2: J2.13, U1.1 (PE2)
PE3: J2.14, U1.2 (PE3)
PE4: J2.15, U1.3 (PE4)
PE5: J2.16, U1.4 (PE5)
PE6: J2.17, U1.5 (PE6)
PE7: J2.18, U1.58 (PE7)
PE8: J2.19, U1.59 (PE8)
PE9: J2.20, U1.60 (PE9)
PE10: J2.7, U1.63 (PE10)
PE11: J2.8, U1.64 (PE11)
PE12: J2.9, U1.65 (PE12)
PE13: J2.10, U1.66 (PE13)
PE14: J2.11, U1.67 (PE14)
PE15: J2.12, U1.68 (PE15)
PF0: J2.21, U1.10 (PF0)
PF1: J2.22, U1.11 (PF1)
PF2: J2.29, U1.12 (PF2)
PF3: J2.30, U1.13 (PF3)
PF4: J2.31, U1.14 (PF4)
PF5: J2.32, U1.15 (PF5)
PF6: J2.33, U1.18 (PF6)
PF7: J2.34, U1.19 (PF7)
PF8: J2.35, U1.20 (PF8)
PF9: J2.36, U1.21 (PF9)
PF10: J2.23, U1.22 (PF10)
PF11: J2.24, U1.49 (PF11)
PF12: J2.25, U1.50 (PF12)
PF13: J2.26, U1.53 (PF13)
PF14: J2.27, U1.54 (PF14)
PF15: J2.28, U1.55 (PF15)
PG0: J2.37, U1.56 (PG0)
PG1: J2.38, U1.57 (PG1)
PG2: J2.45, U1.87 (PG2)
PG3: J2.46, U1.88 (PG3)
PG4: J2.47, U1.89 (PG4)
PG5: J2.48, U1.90 (PG5)
PG6: J2.49, U1.91 (PG6)
PG7: J2.50, U1.92 (PG7)
PG8: J2.51, U1.93 (PG8)
PG9: J2.52, U1.124 (PG9)
PG10: J2.39, U1.125 (PG10)
PG11: J2.40, U1.126 (PG11)
PG12: J2.41, U1.127 (PG12)
PG13: J2.42, U1.128 (PG13)
PG14: J2.43, U1.129 (PG14)
PG15: J2.44, U1.132 (PG15)
PH: C23.2, D7.1 (K), L1.1, U2.8 (PH)
SS: C28.1, U2.4 (SS)
USB_DM: U1.103 (PA11), U3.3 (I/O2)
USB_DM_P: J3.A7 (D-), J3.B7 (D-), U3.4 (I/O2)
USB_DP: U1.104 (PA12), U3.1 (I/O1)
USB_DP_P: J3.A6 (D+), J3.B6 (D+), U3.6 (I/O1)
VBAT: C48.1, R21.2, U1.6 (VBAT)
VBUS: F1.1, J3.A4 (VBUS), J3.A9 (VBUS), J3.B4 (VBUS), J3.B9 (VBUS), R12.1, U3.5 (VBUS)
VBUS_F: D5.2 (A), F1.2
VBUS_SENSE: R12.2, R13.1
VCAP: C40.1, C41.1, TP3.1, U1.71 (VCAP), U1.106 (VCAP)
VDDA: C42.1, C43.1, FB1.2, R20.1, U1.33 (VDDA)
VREF+: C44.1, C45.1, R20.2, U1.32 (VREF+)

Notes on the sheet:
电源输入与DCDC
USB(ESD保护)
MCU电源去耦(每VDD脚100nF就近+4.7uFx2, VCAPx2=2.2uF)
时钟(HSE 8MHz / LSE 32.768kHz)
复位 / BOOT0 / SWD
指示与人机
IO扩展(全部GPIO, PA13/14/PB3=SWD, PA11/12=USB 除外)

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
Board: 4 copper layers, 85.0 x 65.0 mm, 82 parts (0 on the bottom side), 141 nets.

Other parts of the board:
H1, H2, H3, H4: M3; MountingHole_3.2mm_M3_Pad

File kicad/bom.csv:

"Reference","Value","Footprint","QUANTITY"
"C20,C23,C45,C47","100n","Capacitor_SMD:C_0402_1005Metric","4"
"C21,C22","10uF","Capacitor_SMD:C_0805_2012Metric","2"
"C24,C25","47uF","Capacitor_SMD:C_1206_3216Metric","2"
"C26","1nF","Capacitor_SMD:C_0402_1005Metric","1"
"C27","47pF","Capacitor_SMD:C_0402_1005Metric","1"
"C40,C41","2.2uF","Capacitor_SMD:C_0603_1608Metric","2"
"C42,C44,C46","1uF","Capacitor_SMD:C_0603_1608Metric","3"
"C43,C48,C54,C55,C60-C70","100nF","Capacitor_SMD:C_0402_1005Metric","15"
"C50-C53","18pF","Capacitor_SMD:C_0402_1005Metric","4"
"C71,C72","4.7uF","Capacitor_SMD:C_0603_1608Metric","2"
"D5-D7","SS34","Diode_SMD:D_SMA","3"
"D8","PWR_GREEN","LED_SMD:LED_0603_1608Metric","1"
"D9","USER_BLUE","LED_SMD:LED_0603_1608Metric","1"
"F1","500mA","Fuse:Fuse_1206_3216Metric","1"
"FB1","600R@100MHz","Inductor_SMD:L_0603_1608Metric","1"
"J1,J2","GPIO","Connector_PinHeader_2.54mm:PinHeader_2x28_P2.54mm_Vertical","2"
"J3","USB_C","Connector_USB:USB_C_Receptacle_HRO_TYPE-C-31-M-12","1"
"J4","SWD","Connector_PinHeader_2.54mm:PinHeader_1x06_P2.54mm_Vertical","1"
"J5","BOOT","Connector_PinHeader_2.54mm:PinHeader_1x03_P2.54mm_Vertical","1"
"J6","5VIN","Connector_PinHeader_2.54mm:PinHeader_1x02_P2.54mm_Vertical","1"
"L1","6.8uH/4A","Inductor_SMD:L_Bourns_SRP7028A_7.3x6.6mm","1"
"R10,R11","5.1k","Resistor_SMD:R_0402_1005Metric","2"
"R12","68k","Resistor_SMD:R_0402_1005Metric","1"
"R13,R23","100k","Resistor_SMD:R_0402_1005Metric","2"
"R14","0R","Resistor_SMD:R_0805_2012Metric","1"
"R15","10.2k","Resistor_SMD:R_0402_1005Metric","1"
"R16","3.24k","Resistor_SMD:R_0402_1005Metric","1"
"R17","29.4k","Resistor_SMD:R_0402_1005Metric","1"
"R20,R21","0R","Resistor_SMD:R_0402_1005Metric","2"
"R22","10k","Resistor_SMD:R_0402_1005Metric","1"
"R24,R25","1k","Resistor_SMD:R_0402_1005Metric","2"
"SW1","NRST_KEY","Button_Switch_THT:SW_PUSH_6mm","1"
"SW2","USER_KEY","Button_Switch_THT:SW_PUSH_6mm","1"
"TP1","+3V3","TestPoint:TestPoint_Pad_D1.0mm","1"
"TP2","GND","TestPoint:TestPoint_Pad_D1.0mm","1"
"TP3","VCAP","TestPoint:TestPoint_Pad_D1.0mm","1"
"TP4","NRST","TestPoint:TestPoint_Pad_D1.0mm","1"
"TP5","BOOT0","TestPoint:TestPoint_Pad_D1.0mm","1"
"TP6","3V3_SW","TestPoint:TestPoint_Pad_D1.0mm","1"
"U1","STM32H743ZIT6","Package_QFP:LQFP-144_20x20mm_P0.5mm","1"
"U2","TPS54331DDAR","Package_SO:SOIC-8-1EP_3.9x4.9mm_P1.27mm_EP2.29x3mm","1"
"U3","USBLC6-2SC6","Package_TO_SOT_SMD:SOT-23-6","1"
"X1","8MHz","Crystal:Crystal_SMD_3215-2Pin_3.2x1.5mm","1"
"X2","32.768kHz","Crystal:Crystal_SMD_3215-2Pin_3.2x1.5mm","1"

## Code that names these connections

File hardware/reference-based-v1/DESIGN_MANIFEST.yaml:

project:
  name: h743_dev_v1
  branch: reference-based-v1
  mcu: STM32H743ZIT6
  package: LQFP144
  pcb_layers: 4

interfaces:
  usb_fs:
    role: device
    connector: USB-C
    speed: USB2_FULL_SPEED_12M
    pins:
      dm: PA11
      dp: PA12
      vbus_sense: PA9
    notes:
      - CC1/CC2 use Rd
      - DFU/CDC/HID maintenance port
      - no USB-PD

  usb_hs:
    role: host
    connector: USB-A
    speed: USB2_HIGH_SPEED_480M
    controller: STM32H743_OTG_HS
    phy:
      family: USB3320C_USB3300_ULPI
      exact_part: TBF_AFTER_PROCUREMENT_REVIEW
    pins:
      d0: PA3
      ck: PA5
      d1: PB0
      d2: PB1
      d3: PB10
      d4: PB11
      d5: PB12
      d6: PB13
      d7: PB5
      stp: PC0
      dir: PC2
      nxt: PC3
    vbus:
      source: SYS_5V
      current_limited_switch: REQUIRED
      overcurrent_feedback: REQUIRED
    notes:
      - electrically USB 2.0 HS, not USB 3.x SuperSpeed
      - route D+/D- as 90-ohm differential
      - ULPI bus is critical and manually constrained

  ethernet:
    mac: STM32H743_ETH
    phy: LAN8742A
    mode: RMII
    speed: 10_100M
    connector: RJ45_MAGJACK
    pins:
      ref_clk: PA1
      mdio: PA2
      mdc: PC1
      crs_dv: PA7
      rxd0: PC4
      rxd1: PC5
      tx_en: PG11
      txd0: PG13
      txd1: PG14
    notes:
      - PG14 intentionally replaces MB1364 PB13
      - PB13 is reserved for USB_HS_ULPI_D6

debug:
  swdio: PA13
  swclk: PA14
  swo: PB3
  nrst: NRST

clocks:
  hse:
    pins: [PH0, PH1]
    source: external_crystal
  lse:
    pins: [PC14, PC15]
    source: 32768Hz_crystal
  ulpi:
    frequency: 60MHz
    source: external_phy

power:
  input:
    usb_c_vbus_5v: true
    header_5v: true
  rails:
    SYS_5V:
      purpose: input_and_usb_host_vbus_source
    VDD_3V3:
      purpose: mcu_phy_logic
  rules:
    - host USB VBUS must use current-limited high-side switch
    - VCAP capacitors must be local to MCU
    - VDD33_USB must be locally decoupled
    - PHY local decoupling follows exact selected datasheet

forbidden:
  - claim_usb3_superspeed
  - ethernet_txd1_on_PB13
  - autoroute_ulpi_without_constraints
  - autoroute_usb_differential_pairs_without_constraints
  - split_L2_ground_plane_for_signal_routing

File tools/gen_schematic.py (part):

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
def mcu_net(num: int, name: str) -> str:
    if name == "VCAP":
        return "VCAP"  # AN4938 Rev7 §2.2 + MB1364E sheet 4: tie both pins, local 2.2uF each.
    if name in ("VDD", "VDD33_USB"):
        return "+3V3"
    if name in ("VSS", "VSSA"):
        return "GND"
    return {"VDDA": "VDDA", "VREF+": "VREF+", "VBAT": "VBAT", "PDR_ON": "PDR_ON",
            "NRST": "NRST", "BOOT0": "BOOT0", "PH0": "OSC_IN", "PH1": "OSC_OUT",
            "PC14": "OSC32_IN", "PC15": "OSC32_OUT",
            "PA11": "USB_DM", "PA12": "USB_DP"}.get(name, name)

SWD_GPIO = {"PA13", "PA14", "PB3"}          # 专用 SWD, 不上排针
USB_GPIO = {"PA11", "PA12"}                  # 专用 USB
OSC_GPIO = {"PC14", "PC15", "PH0", "PH1"}    # 晶振占用

def conn(b, inst, pin, net, len_lbl=3.81, len_pwr=5.08):
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    two_pin(b, "Device:R", "R10", "5.1k", FP["R"], 75, 95, "CC1", "GND")
    two_pin(b, "Device:R", "R11", "5.1k", FP["R"], 85, 95, "CC2", "GND")
    # USB 后级: 保险丝 → 二极管合路(电流方向: 输入→+5V, 故 K 极朝 +5V)
    two_pin(b, "Device:Polyfuse", "F1", "500mA", FP["F"], 100, 70, "VBUS", "VBUS_F")
    two_pin(b, "Device:D_Schottky", "D5", "SS34", FP["D"], 120, 70, "+5V", "VBUS_F")
    j6 = b.place("Connector_Generic:Conn_01x02", "J6", "5VIN", FP["H102"], 25, 60)
    conn(b, j6, "1", "5VIN")
    conn(b, j6, "2", "GND")
    two_pin(b, "Device:D_Schottky", "D6", "SS34", FP["D"], 120, 60, "+5V", "5VIN")
    # VBUS 检测分压(DNP, 默认不装)
    two_pin(b, "Device:R", "R12", "68k", FP["R"], 150, 95, "VBUS", "VBUS_SENSE", dnp=True)
    two_pin(b, "Device:R", "R13", "100k", FP["R"], 160, 95, "VBUS_SENSE", "GND", dnp=True)
    # DCDC 主芯片
    u2 = b.place("hagent:TPS54331DDA", "U2", "TPS54331DDAR", FP["DCDC"], 55, 55,
                 custom_block=TPS54331_BLOCK, val_off=(0, 18.5))
    for pin, net in {"1": "BOOT", "2": "+5V", "4": "SS", "5": "FB", "6": "COMP", "7": "GND", "8": "PH", "9": "GND"}.items():
        conn(b, u2, pin, net)
    rc(b, "C28", "10n", FP["C"], 30, 42, "SS", "GND")  # TPS54331 SS 慢启动电容(TI §7.3.5: 内部无软启动, CSS<=27nF)
    two_pin(b, "Device:C", "C20", "100n", FP["C"], 48, 25, "+5V", "GND")          # 输入
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    two_pin(b, "Device:C", "C25", "47uF", FP["C1206"], 168, 120, "3V3_SW", "GND")
    two_pin(b, "Device:R", "R15", "10.2k", FP["R"], 30, 150, "3V3_SW", "FB")  # Sense BEFORE removable current link.
    two_pin(b, "Device:R", "R16", "3.24k", FP["R"], 42, 162, "FB", "GND")
    two_pin(b, "Device:R", "R17", "29.4k", FP["R"], 95, 125, "COMP", "COMP_M")    # II 型补偿
    two_pin(b, "Device:C", "C26", "1nF", FP["C"], 105, 138, "COMP_M", "GND")
    two_pin(b, "Device:C", "C27", "47pF", FP["C"], 85, 138, "COMP", "GND")

    # ================= USB ESD (右上) =================
    b.note("USB(ESD保护)", 340, 20, 2)
    u3 = b.place("Power_Protection:USBLC6-2SC6", "U3", "USBLC6-2SC6", FP["ESD"], 400, 55)
    for pin, net in {"1": "USB_DP", "3": "USB_DM", "4": "USB_DM_P", "5": "VBUS",
                     "6": "USB_DP_P", "2": "GND"}.items():
        conn(b, u3, pin, net)

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    two_pin(b, "Device:R", "R20", "0R", FP["R"], 180, 378, "VDDA", "VREF+")
    two_pin(b, "Device:R", "R21", "0R", FP["R"], 40, 370, "+3V3", "VBAT")
    rc(b, "C48", "100nF", FP["C"], 90, 370, "VBAT", "GND")
    two_pin(b, "Device:R", "R22", "10k", FP["R"], 60, 370, "PDR_ON", "+3V3")

    # ================= 时钟 (下方左) =================
    b.note("时钟(HSE 8MHz / LSE 32.768kHz)", 25, 390, 2)
    two_pin(b, "Device:Crystal", "X1", "8MHz", "Crystal:Crystal_SMD_3215-2Pin_3.2x1.5mm", 40, 330, "OSC_IN", "OSC_OUT")
    two_pin(b, "Device:C", "C50", "18pF", FP["C"], 55, 318, "OSC_IN", "GND")
    two_pin(b, "Device:C", "C51", "18pF", FP["C"], 55, 342, "OSC_OUT", "GND")
    two_pin(b, "Device:Crystal", "X2", "32.768kHz", "Crystal:Crystal_SMD_3215-2Pin_3.2x1.5mm", 110, 330, "OSC32_IN", "OSC32_OUT")
    two_pin(b, "Device:C", "C52", "18pF", FP["C"], 125, 318, "OSC32_IN", "GND")
    two_pin(b, "Device:C", "C53", "18pF", FP["C"], 125, 342, "OSC32_OUT", "GND")

    # ================= 复位/启动/调试 (下方中) =================
    b.note("复位 / BOOT0 / SWD", 200, 390, 2)
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    for pin, net in {"1": "+3V3", "2": "BOOT0", "3": "GND"}.items():
        conn(b, j5, pin, net)
    j4 = b.place("Connector_Generic:Conn_01x06", "J4", "SWD", FP["H106"], 285, 330)
    for pin, net in {"1": "+3V3", "2": "PA13", "3": "PA14", "4": "PB3", "5": "NRST", "6": "GND"}.items():
        conn(b, j4, pin, net)

    # ================= 指示与人机 (右侧下) =================
    b.note("指示与人机", 350, 200, 2)
    two_pin(b, "Device:R", "R24", "1k", FP["R"], 360, 220, "+3V3", "LED_PWR")
    two_pin(b, "Device:LED", "D8", "PWR_GREEN", FP["LED"], 360, 240, "GND", "LED_PWR")
    two_pin(b, "Device:R", "R25", "1k", FP["R"], 390, 220, "+3V3", "LED_USER")
    two_pin(b, "Device:LED", "D9", "USER_BLUE", FP["LED"], 390, 240, "PB0", "LED_USER")
    two_pin(b, "Switch:SW_Push", "SW2", "USER_KEY", FP["SW"], 420, 220, "PC13", "GND")
    two_pin(b, "Device:C", "C55", "100nF", FP["C"], 440, 220, "PC13", "GND")
    # 测试点
    for k, (ref, net) in enumerate([("TP1", "+3V3"), ("TP2", "GND"), ("TP3", "VCAP"),
                                    ("TP4", "NRST"), ("TP5", "BOOT0"), ("TP6", "3V3_SW")]):
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        conn(b, tp, "1", net)

    # ================= IO 排针 (最右, 2x28 x2) =================
    b.note("IO扩展(全部GPIO, PA13/14/PB3=SWD, PA11/12=USB 除外)", 480, 20, 2)
    def header(ref, x, y, nets):
        h = b.place("Connector_Generic:Conn_02x28_Odd_Even", ref, "GPIO", FP["H228"], x, y)
        for pin, net in nets.items():
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
File tools/route_residual.py:

"""Route the small residual set left by the constrained autorouter.

Freerouting is intentionally run before this script.  It is good at the bulk
of the board but may leave a few nets unrouted when the two external signal
layers are crowded.  This pass uses a conservative raster search for a short
F.Cu escape from each SMD pad, changes layer through a through via, and then
uses an inner-layer corridor to the through-hole header pad.  The inner-layer
tracks are accepted only after KiCad DRC and plane refill; the script never
deletes another net's copper.
"""
from __future__ import annotations

import argparse
import math
import pathlib
import sys

import pcbnew as p

sys.path.insert(0, str(pathlib.Path(__file__).parent))
from local_router import route, exact_clear, exact_via_clear
from project_config import PCB, VIA_DIAMETER, VIA_DRILL

RESIDUAL = [
    ("PB11", "U1", "70", "J1", "16"),
    ("PB10", "U1", "69", "J1", "15"),
    ("PB12", "U1", "73", "J1", "17"),
    ("PB15", "U1", "76", "J1", "20"),
    ("PB2", "U1", "48", "J1", "21"),
    ("PD2", "U1", "116", "J1", "50"),
    ("PD3", "U1", "117", "J1", "51"),
    ("PE12", "U1", "65", "J2", "9"),
    ("PE5", "U1", "4", "J2", "16"),
    ("PE7", "U1", "58", "J2", "18"),
    ("PF14", "U1", "54", "J2", "27"),
    ("PF3", "U1", "13", "J2", "30"),
    ("PF4", "U1", "14", "J2", "31"),
    ("PF5", "U1", "15", "J2", "32"),
    ("PG0", "U1", "56", "J2", "37"),
]

def mm(v: float) -> int:
    return p.FromMM(v)

def vec(xy: tuple[float, float]) -> p.VECTOR2I:
    return p.VECTOR2I(mm(xy[0]), mm(xy[1]))

def xy(item) -> tuple[float, float]:
    q = item.GetPosition()
    return q.x / 1e6, q.y / 1e6

def get_pad(board, ref: str, number: str):
    fp = next(f for f in board.GetFootprints() if f.GetReference() == ref)
    # Conn/SW footprints can have duplicate pad numbers.  For this residual
    # set the source is unique and all destination header pads are unique.
    return next(q for q in fp.Pads() if q.GetNumber() == number)

def add_track(board, net, a, b, layer):
    if math.dist(a, b) < 1e-5:
        return
    t = p.PCB_TRACK(board)
    t.SetStart(vec(a))
    t.SetEnd(vec(b))
    t.SetLayer(layer)
    t.SetWidth(mm(0.20))
    t.SetNet(net)
    t.SetLocked(True)
    board.Add(t)

def add_via(board, net, point):
    v = p.PCB_VIA(board)
    v.SetPosition(vec(point))
    v.SetViaType(p.VIATYPE_THROUGH)
    v.SetWidth(mm(VIA_DIAMETER))
    v.SetDrill(mm(VIA_DRILL))
    v.SetLayerPair(p.F_Cu, p.B_Cu)
    v.SetNet(net)
    v.SetLocked(True)
    board.Add(v)

def radial_points(start):
    # Keep a short escape first.  Larger radii are used only where the QFP
    # fanout is already occupied by an existing track.
    for radius in (0.8, 1.2, 1.6, 2.0, 2.5, 3.0, 4.0, 5.0, 6.0, 8.0):
        for angle in range(0, 360, 15):
            a = math.radians(angle)
            yield start[0] + radius * math.cos(a), start[1] + radius * math.sin(a)

def find_path(board, source, target, netcode):
    """Return (F.Cu path, via point, inner path, inner layer)."""
    start, end = xy(source), xy(target)
    for via_point in radial_points(start):
        if not (0.7 < via_point[0] < 84.3 and 0.7 < via_point[1] < 64.3):
            continue
        # A* on F.Cu provides a real escape rather than assuming a straight
        # fanout.  This matters for the 0.5 mm-pitch MCU pads.
        front = route(board, netcode, start, via_point, 0.20, p.F_Cu, 10.0, 0.10)
        if front is None or not exact_clear(board, front, netcode, p.F_Cu):
            continue
        if not exact_via_clear(board, via_point, netcode, VIA_DIAMETER):
            continue
        # Prefer B.Cu because it is the signal layer on this four-layer
        # board; inner layers remain a fallback when the back is occupied.
        for layer in (p.B_Cu, p.In1_Cu, p.In2_Cu):
            inner = route(board, netcode, via_point, end, 0.20, layer, 10.0, 0.20)
            if inner is not None and exact_clear(board, inner, netcode, layer):
                return front, via_point, inner, layer
    return None

def main(only=()):
    board = p.LoadBoard(str(PCB))
    chosen = [x for x in RESIDUAL if not only or x[0] in only]
    for name, src_ref, src_num, dst_ref, dst_num in chosen:
        src = get_pad(board, src_ref, src_num)
        dst = get_pad(board, dst_ref, dst_num)
        result = find_path(board, src, dst, src.GetNetCode())
        if result is None:
            raise RuntimeError(f"no conservative residual route for {name}")
        front, via_point, inner, layer = result
        net = src.GetNet()
        for a, b in zip(front, front[1:]):
            add_track(board, net, a, b, p.F_Cu)
        add_via(board, net, via_point)
        for a, b in zip(inner, inner[1:]):
            add_track(board, net, a, b, layer)
        print(f"{name}: F.Cu escape + via {via_point} + {layer if isinstance(layer, str) else board.GetLayerName(layer)} ({len(inner)-1} segments)", flush=True)

    # Refill after adding through vias/tracks so plane voids are represented in
    # the saved board before the independent CLI DRC is run.
    filler = p.ZONE_FILLER(board)
    filler.Fill(list(board.Zones()))
    p.SaveBoard(str(PCB), board)

if __name__ == "__main__":
    parser = argparse.ArgumentParser()
    parser.add_argument("--nets", nargs="*", default=())
    args = parser.parse_args()
    main(tuple(args.nets))
